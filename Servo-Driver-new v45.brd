# Repository TNCT-Mechatech/Servo-Driver

File README.md:

# Servo-Driver

#### 2024/5/22 設計完成

## how-to-use
編集中

###### Copyright © 2024 awttenani, gota, zenkasan_ki All Rights Reserved.

## EAGLE design Servo-Driver-new v45.brd

Parts:
5V: LED_CHIP_GREEN-1608; LEDC1608X39N_G
BATT: LED_CHIP_RED-1608; LEDC1608X39N_R
C1, C2: 4.7u; CAPC3225X135
C3: 10n; CAPC2012X110
C4, C5: 47u; CAPC3216X135
C6: 330u; CAPAE1030X1050N
C7: 100u; CAPAE1030X1050N
CONT: LED_CHIP_GREEN-1608; LEDC1608X39N_G
D1: 1N5819HW-7; SOD3715X145N
D2: B550C; DIO_B340-13-F
D3, D4: ZENER; DIOM5336X265N
EDGE1: 10046971_019LF; 10046971-019LF
J1: S3B-XH-A(LF)(SN); JST_S3B-XH-A(LF)(SN)
L1: SMNR6045-331MT 330uF; IND_VLS6045EX-331M
L2: SLF12565T-470M2R4-PF; IND_SLF12565T-470M2R4-PF
OUT: LED_CHIP_BLUE-1608; LEDC1608X39N_B
Q1, Q2: TLP185(E); SOIC254P700X230-4N
R1: 10k; RESC2012X65
R2: 1.5k; RESC1608X60
R3: 330; RESC1608X60
R4, R5: 150; RESC1608X60
R6, R7: 4.7k; RESC1608X60
R8, R9: 430; RESC1608X60
RV1: T93YA502JT20; TRIM_PV36W502C01B00
U1: LM2575S-5.0; VREG_TPS79625KTTR
U2: RT8289GSP; SOIC127P599X175-9N

Connections:
+5V: C6.1 (+), L1.1, Q1.6 (COLLECTOR), Q2.6 (COLLECTOR), R4.1, U1.2 (FB)
+9V: C4.1, C5.1, J1.2, L2.1, R1.1, R3.1
+BATT: D3.2 (A), D4.2 (A), EDGE1.P$12 (+BATT), EDGE1.P$13 (+BATT), EDGE1.P$14 (+BATT), EDGE1.P$15 (+BATT), EDGE1.P$16 (+BATT), EDGE1.P$17 (+BATT), EDGE1.P$18 (+BATT), EDGE1.P$19 (+BATT), EDGE1.P$20 (+BATT), EDGE1.P$21 (+BATT), EDGE1.P$22 (+BATT), EDGE1.P$23 (+BATT), R2.1
GND: 5V.1 (C), BATT.1 (C), C1.2, C2.2, C4.2, C5.2, C6.2 (-), C7.2 (-), CONT.1 (C), D1.A, D2.C (A), EDGE1.P$28 (GND), EDGE1.P$29 (GND), EDGE1.P$30 (GND), EDGE1.P$31 (GND), EDGE1.P$32 (GND), EDGE1.P$33 (GND), EDGE1.P$34 (GND), EDGE1.P$35 (GND), EDGE1.P$36 (GND), EDGE1.P$37 (GND), EDGE1.P$38 (GND), EDGE1.P$39 (GND), J1.1, OUT.1 (C), R6.2, R7.2, RV1.2, U1.3 (GND), U1.4 (SW), U1.6 (GND), U2.6 (GND), U2.9 (GND)
GND_IN: EDGE1.P$24 (GND_IN), Q1.3 (CATHODE), Q2.3 (CATHODE)
unnamed: CONT.2 (A), R5.2
unnamed: Q2.1 (ANODE), R9.1
unnamed: 5V.2 (A), R4.2
unnamed: C3.1, U2.1 (BOOT)
unnamed: BATT.2 (A), R2.2
unnamed: D1.C (K), L1.2, U1.1 (COMP)
unnamed: R1.2, RV1.1, U2.4 (FB)
unnamed: C3.2, D2.A (B), L2.2, U2.8 (SW)
unnamed: OUT.2 (A), R3.2
unnamed: Q1.1 (ANODE), R8.1
unnamed: C7.1 (+), D3.1 (C), U1.5 (VIN)
unnamed: C1.1, C2.1, D4.1 (C), U2.7 (VIN)
PWM_IN: EDGE1.P$25 (PWM_IN), R8.2
PWM_OUT: J1.3, Q1.4 (EMITTER), R6.1
VCC_IN: EDGE1.P$27 (VCC_IN), R5.1, R9.2
VCC_OUT: Q2.4 (EMITTER), R7.1, U2.5 (EN)

Notes on the sheet:
フォトカプラ
DC-DC Converter
EDGE
→5V
→6V~(可変)
LED
3pin

Board: 2 copper layers, 65.7 x 36.2 mm, 33 parts (30 on the bottom side), 21 nets.

## Commit log

2024-05-23 ver 1.0

Notices in the files:
Servo-Driver-new v45.brd:
Copyright © 2024 awttenani, guchi, zenkasan_ki All Rights Reserved.
